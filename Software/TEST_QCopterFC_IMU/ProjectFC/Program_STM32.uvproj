# Keil uVision project Program_STM32.uvproj, settings and files
target STM32F405RGT (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F405RGT +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program_Dirver;..\Program_Algorithm;..\Program_Slave;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
    ../Libraries/CMSIS/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_i2c.c
    ../Program/: stm32f4xx_conf.h
  group Driver
    ../Program/: stm32f4_system.c stm32f4_delay.c stm32f4_usart.c stm32f4_i2c.c
  group Program
    ../Program/: experiment_stm32f4.c experiment_stm32f4_it.c QCopterFC_ahrs.c
  group Module
    ../Program/: module_rs232.c module_sensor.c module_mpu9150.c module_ms5611.c
  group Algorithm
    ../Program/: algorithm_moveAve.c algorithm_quaternion.c
