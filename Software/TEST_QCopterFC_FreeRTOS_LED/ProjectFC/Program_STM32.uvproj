# Keil uVision project Program_STM32.uvproj, settings and files
target STM32F405R (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F405R +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\;..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Libraries\FreeRTOS\Source;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Program;..\Program\Algorithms;..\Program\Dirvers;..\Program\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c
    ../Program/: stm32f4xx_conf.h
  group Drivers
    ../Program/Dirvers/: stm32f4_delay.c
  group FreeRTOS
    ../Libraries/FreeRTOS/Source/: port.c croutine.c event_groups.c list.c queue.c tasks.c timers.c heap_1.c
  group Program
    ../Program/: experiment_stm32f4.c
  group Document
    ../: Readme.md
